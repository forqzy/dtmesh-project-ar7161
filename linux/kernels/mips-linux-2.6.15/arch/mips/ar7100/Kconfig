## linux/kernels/mips-linux-2.6.15/arch/mips/ar7100/Kconfig
```kconfig
config  INTELLUS
    bool "Selects jjPlus INTELLUS JA73PF, JA76PF, JA76HX, etc boards"
    depends on MACH_AR7100
```
